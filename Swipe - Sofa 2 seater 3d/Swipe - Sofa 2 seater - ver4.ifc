Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Swipe - Sofa 2 seater - ver4.ifc
Time: 2024-01-15T17:52:44
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (11)
Name
 | Swipe - Sofa 2 seate model_0 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_1 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_2 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_3 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_4 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_5 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_6 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_7 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_8 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_9 - ObjectType: SketchupGroup
 | Swipe - Sofa 2 seate model_10 - ObjectType: SketchupGroup
